# Keil uVision project NanoVM.uvproj, settings and files
target NanoVM (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: NanoVM
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\;..\STM32F4_Discovery;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\CMSIS\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32F4-Discovery;..\kernel
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
    ../: system_stm32f4xx.c NanoVM.c stm32f4xx_it.c array.c debug.c error.c heap.c loader.c native_formatter.c native_lcd.c native_math.c native_stdio.c nvmcomm1.c nvmcomm2.c nvmfile.c nvmstring.c stack.c uart.c vm.c utils.c delay.c native_exception.c native_thread.c
  group STM32F4-Discovery
    ../../../Utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c misc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group Native
    ../STM32F4_Discovery/: adc.c display.c ir_rc5.c mouse.c native_bot.c native_clock.c native_display.c native_impl.c native_irreceiver.c native_ldrsensor.c native_leds.c native_lightbarrier.c native_linedetector.c native_motor.c native_mouse.c native_servo.c native_shuttersensor.c native_wheelencoder.c pid.c pwm.c shift.c wheelencoder.c native_distancesensor.c native_edgedetector.c
  group kernel
    ../: mutex.c
    ../kernel/: scheduler.c task.c context.s
